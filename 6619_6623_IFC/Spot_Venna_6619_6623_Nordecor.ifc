Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Número do projeto
Time: 2024-11-08T18:02:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - IU alternativa 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 08 18:02:13 2024 * Host: fuleco * Database: C:\Users\jujus\AppData\Local\Temp\36f487e0-1f32-4dab-af8b-8024b0656fcb\d6e622c5-2d50-418c-921a-b9b2ee0060c8\ifc * Database version: 5507 * Database creation date: Fri Nov 08 18:02:12 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 08 18:02:13 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 08 18:02:13 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Número do projeto
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 0
